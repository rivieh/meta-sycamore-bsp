FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_imx8mn-550p2-rev2 = " \
				    file://0001-Add-support-for-imx8mn-550p2-rev2-board.patch \
"

